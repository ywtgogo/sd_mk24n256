# IAR project dspi_interrupt_transfer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; TWR_K24F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK24F25612/drivers; ..; ../../../../../../devices/MK24F25612/utilities; ../../../..; ../../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dspi_interrupt_transfer.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; FRDM_K64F; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK64F12/drivers; ..; ../../../../../../devices/MK64F12/utilities; ../../../..; ../../../../../../devices/MK64F12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group source
    ../: dspi_interrupt_transfer.c spiflash_config.h spiflash_ll.c
  group startup
    ../../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_sbrk.c
