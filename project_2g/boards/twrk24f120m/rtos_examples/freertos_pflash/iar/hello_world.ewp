# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TWR_K24F120M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3_k24/Source/include; ../../../../../rtos/freertos_8.2.3_k24/Source; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: hello_world.srec
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; TWR_K24F120M; TOWER
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group freertos
    ../../../../../rtos/freertos_8.2.3_k24/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_8.2.3_k24/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3_k24/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group source
    ../: FreeRTOSConfig.h fsl_pflash_freertos.c fsl_pflash_freertos.h
  group startup
    ../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_sbrk.c
