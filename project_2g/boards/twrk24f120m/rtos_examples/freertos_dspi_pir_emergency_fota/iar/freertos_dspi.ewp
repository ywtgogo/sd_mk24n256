# IAR project freertos_dspi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER; DRIVER_RF_PROJECT
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../7139; ../../../../../devices/MK24F25612/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: fota_console.srec
  ILINK.IlinkOutputFile: freertos_dspi.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 3
  group 7139
    ../7139/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h SPI_A7139.c SPI_A7139.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group drivers/freertos
    ../../../../../devices/MK24F25612/drivers/: fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_uart_freertos.c fsl_uart_freertos.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group source
    ../: fota_test.c freertos_dspi.c FreeRTOSConfig.h hb_protocol.c hb_protocol.h message.h simple_console.c simple_console.h
  group startup
    ../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_sbrk.c
