<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\freertos_dspi_rf _spirit1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


