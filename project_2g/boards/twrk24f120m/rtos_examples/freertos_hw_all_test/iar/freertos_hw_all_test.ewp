# IAR project freertos_hw_all_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER; PLC_INTERFACE_ENNABLE
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3_k24/Source/include; ../../../../../rtos/freertos_8.2.3_k24/Source; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../drv_st7580; ../../../../../devices/MK24F25612/utilities; ../../..; ../../../../../devices/MK24F25612; ../../../../../modem_flash; ../../../../../7139
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_uart.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 3
  group 7139
    ../../../../../7139/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h SPI_A7139.c SPI_A7139.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK24F25612/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_freertos.c fsl_uart_freertos.h
  group drv_st7580
    ../drv_st7580/: drv_st7580.c drv_st7580.h drv_st7580_fsm.h plc_codec_ping.c plc_codec_ping.h plc_k24_api.h plc_k24_error.h plc_k24_timer.h plc_k24_types.h test_ping_common.c test_ping_sn.c Timer.c uartplc_k24.c uartplc_k24.h
  group freertos
    ../../../../../rtos/freertos_8.2.3_k24/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_8.2.3_k24/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3_k24/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group modem_flash
    ../../../../../modem_flash/: spiflash_config.h spiflash_ll.c
  group source
    ../: FreeRTOSConfig.h profiling.c shell.c shell_cmd.h test_battery.c test_common.h test_key.c test_led.c test_main.c test_peak_sensor.c test_rtc.c test_speaker.c test_spi.c test_uart.c
  group startup
    ../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_shell.c fsl_shell.h
