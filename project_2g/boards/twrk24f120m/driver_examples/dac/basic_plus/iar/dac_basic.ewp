# IAR project dac_basic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; TWR_K24F120M; TOWER; AUDIO_PLAY
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MK24F25612/drivers; ..; ../../../../../../devices/MK24F25612/utilities; ../../../..; ../../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: dac_basic.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; TWR_K24F120M; TOWER
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group source
    ../: dac_basic.c wav_record.h
  group startup
    ../../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h
