# IAR project freertos_dspi_rf _spirit1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER; DRIVER_RF_PROJECT
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK24F25612; ../BSP/Components/Spirit1/Kinetis_Nucleo_SPIRIT1_Util/Inc; ../BSP/Components/Spirit1/SPIRIT1_Library/Inc; ../BSP/Kinetis_Nucleo/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: freertos_dspi_rf _spirit1.srec
  ILINK.IlinkOutputFile: freertos_dspi.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK24F25612/drivers; ..; ../../../../../devices/MK24F25612/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MK24F25612
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_gpio.c fsl_gpio.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group drivers/freertos
    ../../../../../devices/MK24F25612/drivers/: fsl_dspi_freertos.c fsl_dspi_freertos.h
  group freertos
    ../../../../../rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Kinetis_Nucleo/Src
    ../BSP/Kinetis_Nucleo/Src/: SDK_EVAL_Spi_Driver.c
  group Kinetis_Nucleo_SPIRIT1_Util/Inc
    ../BSP/Components/Spirit1/Kinetis_Nucleo_SPIRIT1_Util/Inc/: SDK_Configuration_Common.h SPIRIT_SDK_Util.h
  group Kinetis_Nucleo_SPIRIT1_Util/Src
    ../BSP/Components/Spirit1/Kinetis_Nucleo_SPIRIT1_Util/Src/: SPIRIT_SDK_Util.c
  group source
    ../: freertos_dspi.c FreeRTOSConfig.h hb_protocol.h message.h SDK_BasicGeneric_A.c
  group SPIRIT1_Library/Inc
    ../BSP/Components/Spirit1/SPIRIT1_Library/Inc/: MCU_Interface.h SPIRIT_Aes.h SPIRIT_Calibration.h SPIRIT_Commands.h SPIRIT_Config.h SPIRIT_Csma.h SPIRIT_DirectRF.h SPIRIT_General.h SPIRIT_Gpio.h SPIRIT_Irq.h SPIRIT_LinearFifo.h SPIRIT_Management.h SPIRIT_PktBasic.h SPIRIT_PktCommon.h SPIRIT_PktMbus.h SPIRIT_PktStack.h SPIRIT_Qi.h SPIRIT_Radio.h SPIRIT_Regs.h SPIRIT_Timer.h SPIRIT_Types.h
  group SPIRIT1_Library/Src
    ../BSP/Components/Spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group startup
    ../../../../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group utilities
    ../../../../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h
