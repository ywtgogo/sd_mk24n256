# IAR project project_k24.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 NXP MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER; USE_RTOS=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F; ../../rtos/freertos_8.2.3_k24/Source/include; ../../rtos/freertos_8.2.3_k24/Source; ../../middleware/lwip_1.4.1; ../../middleware/lwip_1.4.1/port; ../../middleware/lwip_1.4.1/port/arch; ../../middleware/lwip_1.4.1/src; ../../middleware/lwip_1.4.1/src/include; ../../middleware/lwip_1.4.1/src/include/ipv4; ../../middleware/lwip_1.4.1/src/include/ipv4/lwip; ../../middleware/lwip_1.4.1/src/include/lwip; ../../middleware/lwip_1.4.1/src/include/netif; ../../middleware/lwip_1.4.1/src/include/posix; ../../middleware/lwip_1.4.1/src/netif/ppp; ../../devices/MK24F25612/drivers; ../../devices/MK24F25612/utilities; ../../devices/MK24F25612; ../../devices; ../../CMSIS/Include; ..; ../../7139; ../../protocol; ../../crypto; ../../http_client; ../../tools; ../../modem_flash; ../../modem_gprs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: project_k24.srec
  ILINK.IlinkOutputFile: project_k24.out
  ILINK.IlinkIcfFile: MK24FN256xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; FSL_RTOS_FREE_RTOS; TWR_K24F120M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: freertos_hello.out
  group 7139
    ../../7139/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h SPI_A7139.c SPI_A7139.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group crypto
    ../../crypto/: aes256.c aes256.h sha1.c sha1.h
  group drivers
    ../../devices/MK24F25612/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_pflash_freertos.c fsl_pflash_freertos.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_freertos.c fsl_uart_freertos.h fsl_wdog.c fsl_wdog.h
  group freertos
    ../../rtos/freertos_8.2.3_k24/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../rtos/freertos_8.2.3_k24/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../rtos/freertos_8.2.3_k24/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../rtos/freertos_8.2.3_k24/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group http_client
    ../../http_client/: homebox_bronze_info.h http_client.c http_client.h httpserver-netconn.h json_string.h uplink_protocol.c uplink_protocol.h uplink_task.c uplink_task.h
  group lwip_1.4.1/port
    ../../middleware/lwip_1.4.1/port/: lwipopts.h sys_arch.c
  group lwip_1.4.1/port/arch
    ../../middleware/lwip_1.4.1/port/arch/: cc.h perf.h sys_arch.h
  group lwip_1.4.1/src/api
    ../../middleware/lwip_1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_1.4.1/src/core
    ../../middleware/lwip_1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwip_1.4.1/src/core/ipv4
    ../../middleware/lwip_1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_1.4.1/src/core/snmp
    ../../middleware/lwip_1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip_1.4.1/src/include/ipv4/lwip
    ../../middleware/lwip_1.4.1/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip_1.4.1/src/include/lwip
    ../../middleware/lwip_1.4.1/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
  group lwip_1.4.1/src/include/netif
    ../../middleware/lwip_1.4.1/src/include/netif/: etharp.h ppp_oe.h pppif.h slipif.h
  group lwip_1.4.1/src/include/posix
    ../../middleware/lwip_1.4.1/src/include/posix/: netdb.h
  group lwip_1.4.1/src/include/posix/sys
    ../../middleware/lwip_1.4.1/src/include/posix/sys/: socket.h
  group lwip_1.4.1/src/netif
    ../../middleware/lwip_1.4.1/src/netif/: etharp.c pppif.c slipif.c
  group lwip_1.4.1/src/netif/ppp
    ../../middleware/lwip_1.4.1/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_impl.h ppp_md5.c ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h
  group modem_flash
    ../../modem_flash/: spiflash_config.h spiflash_ll.c
  group modem_gprs
    ../../modem_gprs/: modem_AT.c modem_AT.h
  group source
    ../../protocol/: fota.c freertos_dspi.c hb_protocol.c hb_protocol.h log_task.c log_task.h main.c message.h mode_ctl.c pflash_hub.c pflash_hub.h pflash_sensor.c pflash_sensor.h protocol_2_17.c protocol_2_17.h rtc_fun.c rtc_fun.h uart_ppp.c wdog.c
    ../: FreeRTOSConfig.h
  group startup
    ../../devices/MK24F25612/iar/: startup_MK24F25612.s
    ../../devices/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
  group tools
    ../../tools/: simple_console.c simple_console.h
  group utilities
    ../../devices/MK24F25612/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_sbrk.c
